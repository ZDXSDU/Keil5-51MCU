#include <REGX52.H>
#include "MatrixLED.H"
unsigned char code animation[] = {
	0x00,0x00,0x00,0x18,0x18,0x00,0x00,0x00,
	0x00,0x00,0x3C,0x3C,0x3C,0x3C,0x00,0x00,
	0x00,0x7E,0x7E,0x7E,0x7E,0x7E,0x7E,0x00,
	0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,0xFF,
	0x7E,0xBD,0xDB,0xE7,0xE7,0xDB,0xBD,0x7E,
	0x7E,0xBD,0xC3,0xC3,0xC3,0xC3,0xBD,0x7E,
	0x7E,0x81,0x81,0x81,0x81,0x81,0x81,0x7E,
	0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
	0x00,0x00,0x00,0x00,0x08,0x00,0x00,0x00,
};
void main()
{
	// i:      当前屏幕中的每一列的字模
	// offset: 屏幕的偏移量，即当前是第几屏幕
	// count:  计次。即当前屏幕循环多少次以后开始显示下一屏
	unsigned char i, offset = 0, count = 0;	
	MatrixLED_Init();
	while(1)
	{
		for(i = 0; i < 8; i++)
		{
			MatrixLEDShowColumn(i, animation[i + offset]);
		}
		count++;
		if(count > 18)
		{
			count = 0;
			offset += 8;
			if(offset > 96)
				offset = 0;			
		}
	}
}